# Keil uVision project Fiscopter.uvproj, settings and files
target Fiscopter (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Motors
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F30X,
  c include: .\..\;..\..\..\STM32F3-Discovery_FW_V1.1.0\Libraries\CMSIS\Device\ST\STM32F30x\Include;..\..\..\STM32F3-Discovery_FW_V1.1.0\Libraries\STM32F30x_StdPeriph_Driver\inc;..\..\..\STM32F3-Discovery_FW_V1.1.0\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\STM32F3-Discovery_FW_V1.1.0\Utilities\STM32F3_Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group User
    ../: main.c init.c system_stm32f30x.c stm32f30x_it.c system_control.c usart.c
  group STM32F30x_StdPeriph_Driver
    ../../../STM32F3-Discovery_FW_V1.1.0/Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_rcc.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_exti.c stm32f30x_spi.c stm32f30x_i2c.c stm32f30x_usart.c
  group STM32F3-Discovery
    ../../../STM32F3-Discovery_FW_V1.1.0/Utilities/STM32F3_Discovery/: stm32f3_discovery.c stm32f3_discovery_lsm303dlhc.c stm32f3_discovery_l3gd20.c
  group MDK-ARM
    ./: startup_stm32f30x.s
